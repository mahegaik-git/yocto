SUMMARY = "Userspace framebuffer boot logo based on usplash"
DESCRIPTION = "My PSplashs information."

LICENSE = "GPLv2+"
LIC_FILES_CHKSUM = "file://psplash.h;beginline=1;endline=8;md5=8f232c1e95929eacab37f00900580224"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
