

FILESEXTRAPATHS_prepend:= "${THISDIR}/files:"
SPLASH_IMAGES ="file://color-bar.png;outsuffix=default"
