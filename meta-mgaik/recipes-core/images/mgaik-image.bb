# lrd-image-prod.bb: Carrier Linux Reference Distribution production image

SUMMARY = "${DISTRO_NAME} Production Image"
require recipes-core/images/mgaik-image-minimal.inc

