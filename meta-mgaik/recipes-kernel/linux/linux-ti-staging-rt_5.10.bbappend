# RT Linux Kernel
require recipes-kernel/linux/linux-ti-staging-mg.inc

