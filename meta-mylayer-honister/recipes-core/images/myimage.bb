
inherit core-image

LICENSE = "CLOSED"

IMAGE_INSTALL += " \
	fbida \
	"
